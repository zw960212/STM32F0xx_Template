# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030C8,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\APP;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../Libraries/CMSIS/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group CMSIS
    ../Libraries/CMSIS/STM32F0xx/Include/: system_stm32f0xx.h stm32f0xx.h
    ../Libraries/CMSIS/Include/: core_cm0.h
  group FWLIB
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group APP
    ../APP/: main.c stm32f0xx_it.c system_stm32f0xx.c
  group BSP
    ../BSP/: bsp_led.c bsp_led.h bsp_key.c bsp_key.h
  group DOC
    ../Doc/: Readme.txt
